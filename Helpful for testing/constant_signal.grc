options:
  parameters:
    generate_options: qt_gui
    id: constant_signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: iio_pluto_sink_0_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '3520'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '435000000'
    samplerate: '96000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '35000'
    filter_source: '''Auto'''
    frequency: '435000000'
    gain1: '''manual'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*3
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', iio_pluto_sink_0_1, '0']
- [analog_const_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
