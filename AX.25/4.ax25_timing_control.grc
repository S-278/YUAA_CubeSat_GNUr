options:
  parameters:
    author: CubeSat
    category: Custom
    generate_options: qt_gui
    id: ax25_tx2
    output_language: python
    run: 'False'
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '0'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: df2
  id: variable
  parameters:
    value: '14'
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '600'
  states: {}
- name: length_packet
  id: variable
  parameters:
    comment: packet length = 1 byte for df1 + x bytes for df2 (includes CR) + 2 byte checksum
    value: df2+3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '80'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/blast-mr-sparks/test.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Text files/AX.25_tx.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Generate Byte Stream
      Pack bits into stream of bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '83'
    type: byte
  states: {}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: sps
    sensitivity: 2*np.pi*freq_dev/samp_rate
  states: {}
- name: iio_pluto_sink_0_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '89.75'
    bandwidth: '20000000'
    buffer_size: 83*8*sps
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: int(435e6)
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: USRP RX Gain
    type: eng_float
    value: '0'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: int(435e6)
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    comment: |-
      The modulator needs some time to stabilize as the 
      modulated carrier wave goes from zero up to full power.
      Therefore, extra preamble and postamble bytes were added to each transmitted packet.

      The output is an unpacked binary stream.
    crc_poly: '4129'
    has_crc: 'True'
    preamble_bytes: '20'
    sync: '0xAA7E'
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tagged_stream
  states: {}

connections:
- [blocks_correctiq_0, '0', iio_pluto_sink_0_1, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_correctiq_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_gfsk_mod_0, '0', blocks_correctiq_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_repack_bits_bb_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, var_len_packet_creator_0, in]
- [var_len_packet_creator_0, out, pdu_pdu_to_tagged_stream_0_1, pdus]
- [virtual_source_1, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
