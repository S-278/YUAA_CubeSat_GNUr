options:
  parameters:
    generate_options: qt_gui
    id: ax25_r2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: Text files/header.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Text files/AX.25_message.txt
    repeat: 'False'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_file_sink_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
