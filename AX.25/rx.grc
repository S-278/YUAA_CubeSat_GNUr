options:
  parameters:
    author: CubeSat
    category: Custom
    generate_options: qt_gui
    id: ax25_rx
    output_language: python
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '0'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 96000*4
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: AX.25_rx.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/blast-mr-sparks/Documents/summer/transceiver/obc.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/blast-mr-sparks/Documents/summer/transceiver/raw.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/blast-mr-sparks/Documents/summer/transceiver/ax.25/ax25_tx.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: '10'
    sensitivity: 2*np.pi*freq_dev/samp_rate
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.06'
    max_dev: '0.008'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '40'
    ted_gain: '0.15'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '100000'
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,1
    label1: Output
    marker1: '1'
    name: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Binary Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: int(435e6)
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: USRP RX Gain
    type: eng_float
    value: '0'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: si446x_var_len_packet_handler_1_0
  id: si446x_var_len_packet_handler
  parameters:
    check_crc: 'True'
    crc_poly: '4129'
    has_crc: 'True'
    is_verbose: 'True'
    sync: '0xAA7E'
  states: {state: disabled}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: int(435e6)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: resampled
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: resampled
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_2, '0']
- [digital_gfsk_mod_0_0, '0', blocks_correctiq_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [satellites_ax25_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [si446x_var_len_packet_handler_1_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [virtual_source_0_0_0, '0', si446x_var_len_packet_handler_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
