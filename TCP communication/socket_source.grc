options:
  parameters:
    author: mettus
    category: Custom
    generate_options: qt_gui
    id: demo_gmsk
    output_language: python
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: k3 (IP3)
    start: '-.1'
    step: '0.001'
    stop: '0'
    value: '0'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency Offset
    start: '-0.5'
    step: '0.001'
    stop: '0.5'
    value: '0'
  states: {}
- name: i_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: I offset
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: magbal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: IQ Magnitude Imbalance
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: phase_noise_mag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1,1
    label: Phase Noise Mag (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: phasebal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: IQ Phase Imbalance
    start: '0'
    step: '0.1'
    stop: '45'
    value: '0'
  states: {}
- name: q_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Q offset
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/blast-mr-sparks/Documents/New Relevant Cubesat Folder/test.txt
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: '10'
    sensitivity: 2*np.pi*9600/96000
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.06'
    max_dev: '0.008'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '10'
    ted_gain: '0.15'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: localhost
    port: '2000'
    server: 'False'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: int(437.085e6)
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: USRP RX Gain
    type: eng_float
    value: '0'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: int(437.085e6)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [digital_gfsk_mod_0, '0', blocks_throttle_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_0, '0']
- [network_tcp_source_0, '0', digital_gfsk_mod_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_2_0, '0']
- [satellites_ax25_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
