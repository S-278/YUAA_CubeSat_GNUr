options:
  parameters:
    generate_options: no_gui
    id: tcp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../hello_world.txt
    repeat: 'True'
    type: byte
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: localhost
    mode: '1'
    port: '2000'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
