options:
  parameters:
    generate_options: qt_gui
    id: tcp_basic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../tcp_test.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/blast-mr-sparks/Documents/New Relevant Cubesat Folder/TCP communication/hello_world.txt
    repeat: 'True'
    type: byte
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: localhost
    mode: '1'
    port: '2001'
    type: byte
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: localhost
    port: '2000'
    server: 'False'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', network_tcp_sink_0, '0']
- [network_tcp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
