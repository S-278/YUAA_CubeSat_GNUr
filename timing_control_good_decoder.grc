options:
  parameters:
    author: CubeSat
    category: Custom
    generate_options: qt_gui
    id: timing_control_good_decoder
    output_language: python
  states: {}

blocks:
- name: TED_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1.5'
    value: '0.12'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: damping_factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: df2
  id: variable
  parameters:
    value: '9'
  states: {}
- name: doppler
  id: variable
  parameters:
    value: tx_freq
  states: {}
- name: doppler_shift
  id: variable
  parameters:
    value: doppler-tx_freq
  states: {}
- name: endurosat_ES_Symbol_to_PDU_plus_CR_0
  id: endurosat_ES_Symbol_to_PDU_plus_CR
  parameters: {}
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '600'
  states: {}
- name: gps_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gui_shift
  id: variable_qtgui_range
  parameters:
    start: '-100000'
    step: '1000'
    stop: '100000'
    value: '0'
  states: {}
- name: length_packet
  id: variable
  parameters:
    comment: packet length = 1 byte for df1 + x bytes for df2 (includes CR) + 2 byte checksum
    value: df2+3
  states: {}
- name: loop_bandwidth
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.06'
  states: {}
- name: offset
  id: variable
  parameters:
    value: doppler_shift+50000
  states: {}
- name: qd_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '300'
    value: samp_rate/(2*math.pi*freq_dev)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: USRP RX Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: standoff_shift
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tcp_in
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: tx_attn
  id: variable_qtgui_range
  parameters:
    label: USRP TX Attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '30'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: qd_gain
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/blast-mr-sparks/Documents/summer/transceiver/delay.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tcv_esttc_response.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: test_rx.txt
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      this way the default is that the signal is centered around offset + tx_freq which is equal to 435 MHz
      then, any doppler stuff moves it about there
    freq: standoff_shift-+gui_shift-gps_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: standoff_shift+gui_shift+gps_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("ES+R2200")
    period: '500'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Generate Byte Stream
      Pack bits into stream of bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: tcp_in
  states: {state: disabled}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: int(sps)
    sensitivity: 2*np.pi*freq_dev/samp_rate
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damping_factor
    loop_bw: loop_bandwidth
    max_dev: '0.008'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: TED_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {state: disabled}
- name: iio_pluto_sink_0_1
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attn
    bandwidth: '20000000'
    buffer_size: int(44*8*sps)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq-standoff_shift
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '100000'
    filter_source: '''Auto'''
    frequency: rx_freq-standoff_shift
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    mode: '1'
    port: '3333'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Message
    type: string
    value: ES+R2200
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Rx"'
    type: complex
    update_time: '0.0050'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Rx"'
    type: complex
    update_time: '0.010'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_fff
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: '432500000'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: USRP RX Gain
    type: eng_float
    value: '60'
  states: {state: disabled}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_endurosat_deframer_0
  id: satellites_endurosat_deframer
  parameters:
    threshold: '0'
  states: {}
- name: tx_attn
  id: parameter
  parameters:
    label: USRP TX Attenuation
    type: eng_float
    value: '30'
  states: {state: disabled}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: '432500000'
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    comment: |-
      The modulator needs some time to stabilize as the 
      modulated carrier wave goes from zero up to full power.
      Therefore, extra preamble and postamble bytes were added to each transmitted packet.

      The output is an unpacked binary stream.
    crc_poly: '4129'
    has_crc: 'True'
    preamble_bytes: '5'
    sync: '0xAA7E'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: signal
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_correctiq_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_correctiq_0, '0', virtual_sink_1, '0']
- [blocks_freqshift_cc_0, '0', iio_pluto_sink_0_1, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_freqshift_cc_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_freqshift_cc_0_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_message_strobe_0, strobe, endurosat_ES_Symbol_to_PDU_plus_CR_0, msg_in]
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_var_to_msg_0, msgout, qtgui_edit_box_msg_0, val]
- [digital_gfsk_mod_0, '0', blocks_correctiq_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_endurosat_deframer_0, '0']
- [endurosat_ES_Symbol_to_PDU_plus_CR_0, msg_out, var_len_packet_creator_0, in]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [iio_pluto_source_0, '0', blocks_probe_signal_x_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_1, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_1, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_file_sink_1_0, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', network_tcp_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, endurosat_ES_Symbol_to_PDU_plus_CR_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_ax25_deframer_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]
- [satellites_endurosat_deframer_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [var_len_packet_creator_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', digital_gfsk_mod_0, '0']
- [virtual_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_1, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
