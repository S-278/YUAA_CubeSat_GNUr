options:
  parameters:
    generate_options: qt_gui
    id: rotator_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: az_el
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: az_el
  states: {}
- name: gpredict_rotor_0
  id: gpredict_rotor
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4533'
    minEl: '20.0'
    verbose: 'True'
  states: {}

connections:
- [gpredict_rotor_0, az_el, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
