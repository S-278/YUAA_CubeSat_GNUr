options:
  parameters:
    author: Daniel Estevez, M0HXM
    category: Custom
    description: GNUradio Doppler correction module
    generate_options: qt_gui
    id: gr_doppler
    output_language: python
    title: gr-doppler
  states: {}

blocks:
- name: doppler
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {}

connections:
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
