options:
  parameters:
    author: mettus
    category: Custom
    generate_options: qt_gui
    id: demo_gmsk
    output_language: python
  states: {}

blocks:
- name: TED_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1.5'
    value: '0.12'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: doppler
  id: variable
  parameters:
    value: rx_freq
  states: {}
- name: doppler_shift
  id: variable
  parameters:
    value: doppler-rx_freq
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: gps_offset
  id: variable
  parameters:
    value: '1420'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: offset
  id: variable
  parameters:
    value: doppler_shift+5000
  states: {}
- name: qd_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '300'
    value: samp_rate/(2*math.pi*freq_dev)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: qd_gain
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sat_receive.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ax25.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: 3cat1.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      this way the default is that the signal is centered around offset + tx_freq which is equal to 435 MHz
      then, any doppler stuff moves it about there
    freq: offset
    sample_rate: samp_rate*interpolation
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: +offset
    sample_rate: samp_rate*interpolation
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: '500'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Generate Byte Stream
      Pack bits into stream of bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: 50m
    init: '0'
    low: 10m
  states: {}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: '10'
    sensitivity: 2*np.pi*freq_dev/samp_rate
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.06'
    max_dev: '0.008'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: TED_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\n\"\"\"\nCopyright CodeLV\nLicense GPL v3\n\"\"\"\nimport pmt\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.basic_block): \n    \"\"\"Morse code reader\"\"\"\n\n    codes = {\n        '*-': 'A',\n        '-***': 'B',\n        '-*-*': 'C',\n        '-**': 'D',\n        '*': 'E',\n        '**-*': 'F',\n        '--*': 'G',\n        '****': 'H',\n        '**': 'I',\n        '*---': 'J',\n        '-*-': 'K',\n        '*-**': 'L',\n        '--': 'M',\n        '-*': 'N',\n        '---': 'O',\n        '*--*': 'P',\n        '--*-': 'Q',\n        '*-*': 'R',\n        '***': 'S',\n        '-': 'T',\n        '**-': 'U',\n        '***-': 'V',\n        '*--': 'W',\n        '-**-': 'X',\n        '-*--': 'Y',\n        '--**': 'Z',\n\n        '*----': '1',\n        '**---': '2',\n        '***--': '3',\n        '****-': '4',\n        '*****': '5',\n        '-****': '6',\n        '--***': '7',\n        '---**': '8',\n        '----*': '9',\n        '-----': '0',\n\n        '*-*-*-': '.',\n        '--**--': ',',\n        '**--**': '?',\n        '*----*': \"'\",\n        '-*-*--': \"!\",\n\n        '-**-*': \"/\",\n        '-*--*': \"(\",\n        '-*--*-': \")\",\n        '*-***': \"&\",\n        '---***': \":\",\n        '-*-*-*': \";\",\n        '-***-': \"=\",\n        '*-*-*': \"+\",\n        '-****-': \"-\",\n        '**--*-': \"_\",\n        '*-**-*': '\"',\n        '***-**-': '$',\n        '*--*-*': '@',\n\n        '***-*-': '*end*',\n        '********': '*error*',\n        '-*-': '*ok*',\n        '-*-*-': '*start*',\n        '*-*-*': '*new*',\n        '***-*': '*verified*',\n        '*-***': '*wait*',\n    }\n\n    def __init__(\n        self, \n        symbol_spacing=3, \n        word_spacing=5,\n        message_limit=100,\n        message_size_limit=1000,\n    ):  \n        \"\"\"\n        Parameters\n        ----------\n        symbol_spacing: int\n            Spacing between symbols / characters\n        word_spacing: int\n            Spacing between words\n        message_limit: int\n            Max number of words to decode\n        message_size_limit: int\n            Max message size\n\n        \"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Morse code reader',   # will show up in GRC\n            in_sig=[np.int8],\n            out_sig=[]\n        )\n        assert isinstance(symbol_spacing, int), \"Symbol spacing must be int\"\n        assert isinstance(word_spacing, int), \"Word spacing must be int\"\n        assert symbol_spacing < word_spacing, \"Symbol spacing must be less than word spacing\"\n        self.symbol_spacing = symbol_spacing\n        self.word_spacing = word_spacing\n        self.port_name = 'out'\n        self.message_port_register_out(pmt.intern(self.port_name))\n        self.key = []\n        self.message = []\n        self.last_level = False\n        self.spacing = 0\n\n        self.code = '*'\n\n        # Anything over this key size is an error\n        self.key_limit = 8\n\n        # Stop reading after this limit as a sanity check in case something goes haywire\n        self.message_size_limit = message_size_limit\n\n        # Stop reading after this limit as a sanity check in case something goes haywire\n        self.message_limit = message_limit\n\n    def flush_message(self):\n        if not self.message:\n            return\n        self.message_port_pub(pmt.intern(self.port_name), pmt.intern(''.join(self.message)))\n        self.message = []\n\n        # Apply limit to avoid UI freezing if sampling/data is incorrect\n        self.message_limit -= 1\n        if self.message_limit == 0:\n            print(\"Warning: Message limit reached. Decoding stopped\") \n\n    def lookup_code(self):\n        code = ''.join(self.key)\n        self.key = []\n        return self.codes.get(code, \"{}\")\n\n    def general_work(self, input_items, output_items):\n        if self.message_limit > 0:\n            for c in input_items[0]:\n                level = bool(c)\n                last_level = self.last_level\n                self.last_level = level\n                if level and last_level:\n                    # Flat high\n                    #assert self.code == '*', \"Got more than two high samples in a row, is sample rate correct?\" \n                    self.code = '-'\n                elif level:\n                    # Rising edge\n                    self.spacing = 0 \n                    self.code = '*'\n                elif last_level:\n                    # Falling edge\n                    self.spacing = 1 \n                    self.key.append(self.code)\n                    assert len(self.key) <= self.key_limit, f\"Key limit exceeded: {self.key}\"\n                else:\n                    # Flat low\n                    self.spacing += 1\n                    if self.spacing == self.word_spacing:\n                        # End of word\n                        self.flush_message()\n                        self.key = [] \n                    elif self.spacing == self.symbol_spacing and self.key:\n                        # End of key\n                        value = self.lookup_code() # Clears key\n                        self.message.append(value)\n                        assert len(self.message) <= self.message_size_limit, f\"Message size limit exceeded: {self.message}\"\n\n        self.consume(0, len(input_items[0]))\n        return 0\n"
    message_limit: '100'
    message_size_limit: '1000'
    symbol_spacing: '3'
    word_spacing: '5'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: iio_pluto_sink_0_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq-50000
    samplerate: samp_rate*interpolation
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '16384'
    filter_source: '''Auto'''
    frequency: rx_freq-offset+gps_offset
    gain1: '''hybrid'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*interpolation
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '35000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*interpolation
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '55'
    minsize: '54'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interpolation
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"initial"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,1
    label1: Output
    marker1: '1'
    name: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Binary Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*interpolation
    fc: '0'
    fftsize: '1024'
    name: '"Tx"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 9600*interpolation*2
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 9600*interpolation*2
    fc: '0'
    fftsize: '1024'
    name: '"Rx unshifted"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_waterfall_sink_x_3
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tx unshifted"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolation
    type: ccc
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_fff
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: 435000000+2490000
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: USRP RX Gain
    type: eng_float
    value: '70'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_sat_3cat_1_deframer_0
  id: satellites_sat_3cat_1_deframer
  parameters:
    threshold: '0'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: int(437.790e6)
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    comment: |-
      The modulator needs some time to stabilize as the 
      modulated carrier wave goes from zero up to full power.
      Therefore, extra preamble and postamble bytes were added to each transmitted packet.

      The output is an unpacked binary stream.
    crc_poly: '4129'
    has_crc: 'True'
    preamble_bytes: '20'
    sync: '0xAA7E'
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tagged_stream
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: resampled
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tagged_stream
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_float_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_char_0, '0', epy_block_0, '0']
- [blocks_freqshift_cc_0, '0', iio_pluto_sink_0_1, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_freqshift_cc_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_2, '0']
- [digital_gfsk_mod_0, '0', low_pass_filter_2_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_3, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_sat_3cat_1_deframer_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [low_pass_filter_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_2_0, '0', qtgui_waterfall_sink_x_3, '0']
- [low_pass_filter_2_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_repack_bits_bb_1, '0']
- [pdu_random_pdu_0, pdus, var_len_packet_creator_0, in]
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_ax25_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_sat_3cat_1_deframer_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [var_len_packet_creator_0, out, pdu_pdu_to_tagged_stream_0_1, pdus]
- [virtual_source_1, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
